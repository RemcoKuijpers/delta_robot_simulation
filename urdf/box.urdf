Commit message: Changed conveyor geometry

File: urdf/box.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: geometry collision box size=1.71 4 1.08; visual box size=1.71 4 1.08
